# IAR project TemplateProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa039
  ICCARM.CCIncludePath2: ..\..\App; ..\..\Cfg; ..\..\BSP\Board; ..\..\BSP\Board\CAN; ..\..\BSP\Board\LED; ..\..\BSP\Board\UART; ..\..\BSP\Board\CC1101; ..\..\BSP\CPU\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\BSP\CPU\Library\STM32F10x_StdPeriph_Driver\inc; ..\..\Middleware\uC-CPU\ARM-Cortex-M3\IAR; ..\..\Middleware\uC-CPU; ..\..\Middleware\uC-LIB; ..\..\Middleware\uCOS-III\Source; ..\..\Middleware\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\Middleware\FIFO; ..\..\Middleware\Parser
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TemplateProject.srec
  ILINK.IlinkOutputFile: TemplateProject.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: includes.h main.c protocal.h simulate.c stm32f10x_it.c stm32f10x_it.h TaskCC1101.c TaskPcCmdParser.c Wireless_Client.c Wireless_Client.h
    ../../Cfg/: os_app_hooks.c os_app_hooks.h
  group BSP/Board
    ../../BSP/Board/: bsp.c bsp.h
  group BSP/Board/CAN
    ../../BSP/Board/CAN/: can.c can.h
  group BSP/Board/CC1101
    ../../BSP/Board/CC1101/: CC1101.c CC1101.h CC1101_Port.c
  group BSP/Board/LED
    ../../BSP/Board/LED/: LED.c LED.h
  group BSP/Board/UART
    ../../BSP/Board/UART/: UART.c UART.h
  group BSP/CPU/CMSIS
    ../../BSP/CPU/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../../BSP/CPU/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group BSP/CPU/Lib/inc
    ../../BSP/CPU/Library/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/CPU/Lib/src
    ../../BSP/CPU/Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Cfg
    ../../Cfg/: app_cfg.h CC1101_Cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h os_type.h stm32f10x_conf.h
  group MiddleWare/FIFO
    ../../Middleware/FIFO/: Example.c FIFO.c FIFO.h
  group MiddleWare/Parser
    ../../Middleware/Parser/: MF_CRC16.c MF_CRC16.h MF_CRC8.c Parser.h Protocal_Parser.c
  group MiddleWare/uc-CPU
    ../../Middleware/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group MiddleWare/uc-CPU/Port
    ../../Middleware/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group MiddleWare/uc-Lib
    ../../Middleware/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group MiddleWare/uc-Lib/Port
    ../../Middleware/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group MiddleWare/uc-OS
    ../../Middleware/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group MiddleWare/uc-OS/Port
    ../../Middleware/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
